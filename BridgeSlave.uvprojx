# Keil uVision project BridgeSlave.uvprojx, settings and files
target BridgePro (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoraMulti +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Source\UpDrive;.\Source\UserCode;.\Source\UserCode\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UserCode
    ./Source/UserCode/: main.c
    ./Source/UpDrive/: bsp_task.c
  group UpDrive
    ./Source/UpDrive/: bsp.c bsp_rf.c bsp_led.c bsp_mux.c bsp_oledio.c bsp_power.c bsp_ad5933.c bsp_sx1276-LoRa.c
  group LowDrive
    ./Source/UpDrive/: bsp_adc.c bsp_spi1.c bsp_spi2.c bsp_timer.c bsp_i2c_ee.c bsp_uartfifo.c bsp_uartpro.c bsp_systimer.c
  group SysFile
    ./Source/UpDrive/: bsp_userlib.c bsp_tpc.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
